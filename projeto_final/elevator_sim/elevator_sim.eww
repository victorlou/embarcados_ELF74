<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Projects\elevator_sim\elevator_sim.ewp</path>
    </project>
    <batchBuild />
</workspace>

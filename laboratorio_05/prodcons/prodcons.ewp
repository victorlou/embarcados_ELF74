# IAR project prodcons.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C1294NCPDT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\drivers; ..\..\TivaWare_C_Series-2.1.4.178; ..\..\CMSIS-5.6.0\CMSIS\Core\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\Include; ..\..\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: prodcons.bin
  ILINK.IlinkOutputFile: prodcons.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../CMSIS-5.6.0/CMSIS/RTOS2/Include/: cmsis_os2.h
    ../drivers/: driverbuttons.c driverleds.c
    ../../TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    src/: prodcons.c RTX_Config.c rtx_lib.c startup_TM4C1294.s system_TM4C1294_TW.c
    ../../CMSIS-5.6.0/CMSIS/RTOS2/RTX/Library/IAR/IDE/CM4F/Exe/: RTX_CM.a
